Commit message: 0521

File: sim1/urdf/arm_robot.urdf (robot description, URDF)
Before this commit: robot arm_robot, 3 links, 2 joints
Joints:
- joint arm1_joint: axis (none) -> 0 1 0; limit lower=-3.14 upper=3.14 effort=50 velocity=100 -> (none)
